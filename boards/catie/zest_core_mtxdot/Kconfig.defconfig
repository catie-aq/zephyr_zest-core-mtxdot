## boards/catie/zest_core_mtxdot/Kconfig.zest_core_mtxdot
```kconfig
# Copyright (c) 2025 CATIE
# SPDX-License-Identifier: Apache-2.0

config BOARD_ZEST_CORE_MTXDOT
	select SOC_STM32L151XC
```
